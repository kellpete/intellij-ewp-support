# IAR project sample.ewp, settings and files
configuration Debug (ARM, debug)
  group (top)
    ../: TopLevelFile.cpp
  group config
    ../config/: AppSettings.hpp OtherSettings.hpp
  group config/stm32
    ../config/stm32/: settings.h
  group src
    ../src/: main.cpp
  group src/services/watchdog
    ../src/services/wd/: Service.cpp Service.hpp
